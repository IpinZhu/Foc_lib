# Repository IpinZhu/Foc_lib

File README.md:

## 重启Foc项目(Great FOC Restart Project)

### 1.概论和目标

基于STM32系列芯片的HAL库Foc代码库，和配套硬件电路

1.采用基本的Foc算法,支持开环和闭环，提供标准API接口

2.自动PID校准功能（待定）

3.支持有感电机和无感电机

4.引入龙伯格观测器，实现无感滤波

5.Rtos程序，可加入用户自定APP

6.宽电压输入范围和输出大电流

### 2.硬件

1.使用DRV8301作为三路逆变器的控制芯片，将功率模块和控制模块区分成上下半区部分。

2.主控采用STM32F405RGT6

3.提供一个外部SPI,一个CAN总线和一个复用的TypeC口，可同时将设备进行串口通信和作为USB设备使用

##### DRV8301

自带一个TPS54160Buck芯片，可以对6-60v输入进行降压处理，由于实际使用不超过25V，因此选取6-35V的输入范围，输出5V电压

### 3.软件

##### 1.foc.c和foc.h

主要由基本foc算法变换，参照st电机库，使用Q1.15形式（注.无法使用Q1.32格式，计算时会溢出）

##### SVPWM：

##### 定时器配置

分频系数为1-1=0

计数模式为中心计数模式，作用频率为10k，为168M/10K/2

RCR设置为1

### 4.RTOS

主任务

屏幕显示任务

### 5.上位机

懒得写。。。。。。

 Foc_lib

## KiCad design HardWare/Foc.kicad_pcb

Notes on the sheet:
电机2
电机1

Parts:
C36, C37, C42, C44: 2.2nf; C_0603_1608Metric
C38, C39, C40: 2.2uf; C_0603_1608Metric
C41: 22nf; C_0603_1608Metric
C43, C46, C47, C48: 100nf; C_0603_1608Metric
C45: 4.7uf; C_0603_1608Metric
C50, C51, C52: 40nf; C_0603_1608Metric
J4: hall; M1010RS-05P
J5: Conn_01x03; MR30-M
Q7, Q8, Q9, Q10, Q11, Q12: Q_NMOS_SGD; VSONP-8-1EP_5x6_P1.27mm
R29: 18k; R_0603_1608Metric
R30, R31, R32, R33, R36, R37, R41, R42, R45, R46: 2.2; R_0603_1608Metric
R34, R35: 22; R_0603_1608Metric
R43, R48: 0.0005; R_2512_6332Metric
R44, R47, R49: 3.3k; R_0603_1608Metric
U5: DRV8301DCAR; HTSSOP-56-1EP_6.1x14mm_P0.5mm_EP3.61x6.35mm; PARTREV F

Connections:
+3.3V: J4.1, R44.1, R47.1, R49.1, U5.49 (VDD_SPI); also elsewhere on the board
+3.3VA: U5.24 (REF); also elsewhere on the board
/motor2/A: J5.1, Q7.1 (S), Q8.3 (D)
/motor2/B: J5.2, Q9.1 (S), Q10.3 (D)
/motor2/C: J5.3, Q11.1 (S), Q12.3 (D)
/motor2/M2_GH_A: R36.1, U5.47 (GH_A)
/motor2/M2_GH_B: R41.1, U5.42 (GH_B)
/motor2/M2_GH_C: R45.1, U5.37 (GH_C)
/motor2/M2_GL_A: R37.1, U5.45 (GL_A)
/motor2/M2_GL_B: R42.1, U5.40 (GL_B)
/motor2/M2_GL_C: R46.1, U5.35 (GL_C)
/motor2/M2_SH_A: C48.2, U5.46 (SH_A)
/motor2/M2_SH_B: C47.2, U5.41 (SH_B)
/motor2/M2_SH_C: C43.2, U5.36 (SH_C)
/motor2/M2_SL_B: Q10.1 (S), R31.2, R43.1, U5.39 (SL_B)
/motor2/M2_SL_C: Q12.1 (S), R33.2, R48.1, U5.34 (SL_C)
/motor2/SN1: C36.2, R31.1, U5.33 (SN1)
/motor2/SN2: C37.2, R33.1, U5.31 (SN2)
/motor2/SP1: C36.1, R30.1, U5.32 (SP1)
/motor2/SP2: C37.1, R32.1, U5.30 (SP2)
EN_GATE: U5.16 (EN_GATE); also elsewhere on the board
GND: C38.1, C39.1, C40.1, C42.2, C44.2, C50.1, C51.1, C52.1, J4.5, R29.2, U5.28 (AGND), U5.55 (EN_BUCK), U5.57 (GND); also elsewhere on the board
GND1: C45.1, C46.1, Q8.1 (S), R30.2, R32.2, R43.2, R48.2, U5.44 (SL_A); also elsewhere on the board
M2_AH: U5.17 (INH_A); also elsewhere on the board
M2_AL: U5.18 (INL_A); also elsewhere on the board
M2_BH: U5.19 (INH_B); also elsewhere on the board
M2_BL: U5.20 (INL_B); also elsewhere on the board
M2_CH: U5.21 (INH_C); also elsewhere on the board
M2_CL: U5.22 (INL_C); also elsewhere on the board
M2_CS: U5.8 (~SCS); also elsewhere on the board
M2_ENC_A: C52.2, J4.2, R49.2; also elsewhere on the board
M2_ENC_B: C51.2, J4.3, R47.2; also elsewhere on the board
M2_ENC_Z: C50.2, J4.4, R44.2; also elsewhere on the board
M2_SO1: C44.1, R34.2; also elsewhere on the board
M2_SO2: C42.1, R35.2; also elsewhere on the board
unnamed: C38.2, U5.13 (GVDD)
unnamed: C39.2, U5.27 (AVDD)
unnamed: C40.2, U5.23 (DVDD)
unnamed: C41.1, U5.14 (CP1)
unnamed: C41.2, U5.15 (CP2)
unnamed: C43.1, U5.38 (BST_C)
unnamed: C47.1, U5.43 (BST_B)
unnamed: C48.1, U5.48 (BST_A)
unnamed: Q7.2 (G), R36.2
unnamed: Q8.2 (G), R37.2
unnamed: Q9.2 (G), R41.2
unnamed: Q10.2 (G), R42.2
unnamed: Q11.2 (G), R45.2
unnamed: Q12.2 (G), R46.2
unnamed: R29.1, U5.7 (DTC)
unnamed: R34.1, U5.25 (SO1)
unnamed: R35.1, U5.26 (SO2)
SPI_MISO: U5.10 (SDO); also elsewhere on the board
SPI_MOSI: U5.9 (SDI); also elsewhere on the board
SPI_SCK: U5.11 (SCLK); also elsewhere on the board
VDC: C45.2, C46.2, Q7.3 (D), Q9.3 (D), Q11.3 (D), U5.29 (PVDD1); also elsewhere on the board
nFAULT: U5.6 (~FAULT); also elsewhere on the board

Parts:
C1: 6.8nf/100v; C_0603_1608Metric
C2, C3, C9, C12: 2.2nf; C_0603_1608Metric
C4, C5, C6, C16, C20: 2.2uf; C_0603_1608Metric
C7, C11, C14, C17, C18: 100nf; C_0603_1608Metric
C8: 22nf; C_0603_1608Metric
C10: 4.7nf/50v; C_0603_1608Metric
C13: 4.7uf; C_0603_1608Metric
C15: 6.8pf/50v; C_0603_1608Metric
C19: 10uf; C_1210_3225Metric
C21, C22, C23: 40nf; C_0603_1608Metric
D2: ss34; D_SMA
J2: hall; M1010RS-05P
J3: Conn_01x03; MR30-M
L1: 22uH; L_Abracon_ASPI-0630LR
Q1, Q2, Q3, Q4, Q5, Q6: Q_NMOS_SGD; VSONP-8-1EP_5x6_P1.27mm
R1: 52.3k; R_0603_1608Metric
R2: 10k; R_0603_1608Metric
R3: 365k; R_0603_1608Metric
R4: 18k; R_0603_1608Metric
R5, R6, R7, R8, R12, R13, R17, R18, R21, R22: 2.2; R_0603_1608Metric
R9, R10: 22; R_0603_1608Metric
R11, R16: 86.6k; R_0603_1608Metric
R15: R_Trim; R_0603_1608Metric
R19, R24: 0.0005; R_2512_6332Metric
R26, R27, R28: 3.3k; R_0603_1608Metric
U2: DRV8301DCAR; HTSSOP-56-1EP_6.1x14mm_P0.5mm_EP3.61x6.35mm; PARTREV F

Connections:
+3.3V: J2.1, R26.1, R27.1, R28.1, U2.49 (VDD_SPI); also elsewhere on the board
+3.3VA: R15.1, U2.24 (REF); also elsewhere on the board
+5V: C19.2, L1.2, R1.2; also elsewhere on the board
/controller/A: J3.1, Q1.1 (S), Q2.3 (D)
/controller/B: J3.2, Q3.1 (S), Q4.3 (D)
/controller/C: J3.3, Q5.1 (S), Q6.3 (D)
/controller/M1_GH_A: R12.1, U2.47 (GH_A)
/controller/M1_GH_B: R17.1, U2.42 (GH_B)
/controller/M1_GH_C: R21.1, U2.37 (GH_C)
/controller/M1_GL_A: R13.1, U2.45 (GL_A)
/controller/M1_GL_B: R18.1, U2.40 (GL_B)
/controller/M1_GL_C: R22.1, U2.35 (GL_C)
/controller/M1_SH_A: C18.2, U2.46 (SH_A)
/controller/M1_SH_B: C17.2, U2.41 (SH_B)
/controller/M1_SH_C: C11.2, U2.36 (SH_C)
/controller/M1_SL_B: Q4.1 (S), R6.2, R19.1, U2.39 (SL_B)
/controller/M1_SL_C: Q6.1 (S), R8.2, R24.1, U2.34 (SL_C)
/controller/SN1: C2.2, R6.1, U2.33 (SN1)
/controller/SN2: C3.2, R8.1, U2.31 (SN2)
/controller/SP1: C2.1, R5.1, U2.32 (SP1)
/controller/SP2: C3.1, R7.1, U2.30 (SP2)
/controller/SW_BST: C7.2, D2.2 (K), L1.1, U2.50 (PH), U2.51 (PH)
EN_GATE: U2.16 (EN_GATE); also elsewhere on the board
GND: C1.2, C4.1, C5.1, C6.1, C9.2, C10.2, C12.2, C15.2, C19.1, C20.2, C21.1, C22.1, C23.1, D2.1 (A), J2.5, R2.1, R3.1, R4.2, R16.2, U2.28 (AGND), U2.57 (GND); also elsewhere on the board
GND1: C13.1, C14.1, C16.1, Q2.1 (S), R5.2, R7.2, R19.2, R24.2, U2.44 (SL_A); also elsewhere on the board
M1_AH: U2.17 (INH_A); also elsewhere on the board
M1_AL: U2.18 (INL_A); also elsewhere on the board
M1_BH: U2.19 (INH_B); also elsewhere on the board
M1_BL: U2.20 (INL_B); also elsewhere on the board
M1_CH: U2.21 (INH_C); also elsewhere on the board
M1_CL: U2.22 (INL_C); also elsewhere on the board
M1_CS: U2.8 (~SCS); also elsewhere on the board
M1_ENC_A: C23.2, J2.2, R28.2; also elsewhere on the board
M1_ENC_B: C22.2, J2.3, R27.2; also elsewhere on the board
M1_ENC_Z: C21.2, J2.4, R26.2; also elsewhere on the board
M1_SO1: C12.1, R9.2; also elsewhere on the board
M1_SO2: C9.1, R10.2; also elsewhere on the board
M1_TEMP: C20.1, R15.2, R16.1; also elsewhere on the board
unnamed: C1.1, U2.56 (SS_TR)
unnamed: C4.2, U2.13 (GVDD)
unnamed: C5.2, U2.27 (AVDD)
unnamed: C6.2, U2.23 (DVDD)
unnamed: C7.1, U2.52 (BST_BK)
unnamed: C8.1, U2.14 (CP1)
unnamed: C8.2, U2.15 (CP2)
unnamed: C10.1, R11.2
unnamed: C11.1, U2.38 (BST_C)
unnamed: C15.1, R11.1, U2.2 (COMP)
unnamed: C17.1, U2.43 (BST_B)
unnamed: C18.1, U2.48 (BST_A)
unnamed: Q1.2 (G), R12.2
unnamed: Q2.2 (G), R13.2
unnamed: Q3.2 (G), R17.2
unnamed: Q4.2 (G), R18.2
unnamed: Q5.2 (G), R21.2
unnamed: Q6.2 (G), R22.2
unnamed: R1.1, R2.2, U2.3 (VSENSE)
unnamed: R3.2, U2.1 (RT_CLK)
unnamed: R4.1, U2.7 (DTC)
unnamed: R9.1, U2.25 (SO1)
unnamed: R10.1, U2.26 (SO2)
SPI_MISO: U2.10 (SDO); also elsewhere on the board
SPI_MOSI: U2.9 (SDI); also elsewhere on the board
SPI_SCK: U2.11 (SCLK); also elsewhere on the board
VDC: C13.2, C14.2, C16.2, Q1.3 (D), Q3.3 (D), Q5.3 (D), U2.29 (PVDD1), U2.53 (PVDD2), U2.54 (PVDD2); also elsewhere on the board
nFAULT: U2.6 (~FAULT); also elsewhere on the board

Parts:
C24, C25: 20pf; C_0603_1608Metric
C26, C27, C29: 2.2uf; C_0603_1608Metric
C28, C32, C56: 100nf; C_0603_1608Metric
C30, C35: 10uf; C_0603_1608Metric
C31, C33: 1uf; C_0603_1608Metric
C34: 22nf; C_0603_1608Metric
C53, C54, C55, C57, C58, C59, C60, C61: 10uf; C_1210_3225Metric
D1: ss34; D_SMA
D3: LED; D_0805_2012Metric
FB1: FerriteBead; L_0805_2012Metric
J1: 复用Typec; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J6: SWD; PinSocket_1x05_P2.54mm_Vertical
J7: inp; XT30U-M
J8: XH2.54; Molex_CLIK-Mate_502443-0270_1x02-1MP_P2.00mm_Vertical
J9, J10: SPI_conn; M1010RS-06P
R20, R25: 1k; R_0603_1608Metric
R23: 10k; R_0603_1608Metric
R50, R51: 22; R_0603_1608Metric
U1: STM32F415RGTx; LQFP-64_10x10mm_P0.5mm
U3: LP5907MFX-3.3; SOT-23-5
U4: RT9193; SOT-23-5
U6: CH340N; SOP-8_3.9x4.9mm_P1.27mm
U7: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 8M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C35.1, C56.1, J6.5, J9.1, J10.1, R20.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U4.5 (VOUT), U6.5 (VCC), U6.8 (V3), U7.3 (VCC); also elsewhere on the board
+3.3VA: C33.1, U3.5 (OUT); also elsewhere on the board
+5V: C30.1, C31.1, C32.1, D1.2 (K), U3.1 (IN), U3.3 (EN), U4.1 (VIN), U4.3 (EN); also elsewhere on the board
/MCU/CAN_D: U1.62 (PB9), U7.1 (D)
/MCU/CAN_H: J8.1, U7.7 (CANH)
/MCU/CAN_L: J8.2, U7.6 (CANL)
/MCU/CAN_R: U1.61 (PB8), U7.4 (R)
/MCU/EXSPI1_CS: J10.2, U1.55 (PB3)
/MCU/EXSPI_CS: J9.2, U1.50 (PA15)
/MCU/RXD: U1.29 (PB10), U6.7 (RXD)
/MCU/SWCLK: J6.3, U1.49 (PA14)
/MCU/SWDIO: J6.4, U1.46 (PA13)
/MCU/TXD: U1.30 (PB11), U6.6 (TXD)
/MCU/USB_DM: R50.2, U1.44 (PA11)
/MCU/USB_DP: R51.2, U1.45 (PA12)
/MCU/VBUS_S: C29.1, R23.2, R25.1, U1.22 (PA6)
/MCU/nrst: C28.2, J6.2, U1.7 (NRST)
EN_GATE: U1.33 (PB12); also elsewhere on the board
GND: C24.2, C25.2, C26.2, C27.2, C28.1, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C56.2, D3.1 (K), FB1.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J6.1, J8.MP (MountPin), J9.6, J10.6, R25.2, U1.12 (VSSA), U1.18 (VSS), U1.60 (BOOT0), U1.63 (VSS), U3.2 (GND), U4.2 (GND), U6.3 (GND), U7.2 (GND), Y1.2, Y1.4; also elsewhere on the board
GND1: C53.2, C54.2, C55.2, C57.2, C58.2, C59.2, C60.2, C61.2, FB1.1, J7.1; also elsewhere on the board
M1_AH: U1.41 (PA8); also elsewhere on the board
M1_AL: U1.34 (PB13); also elsewhere on the board
M1_BH: U1.42 (PA9); also elsewhere on the board
M1_BL: U1.35 (PB14); also elsewhere on the board
M1_CH: U1.43 (PA10); also elsewhere on the board
M1_CL: U1.36 (PB15); also elsewhere on the board
M1_CS: U1.2 (PC13); also elsewhere on the board
M1_ENC_A: U1.56 (PB4); also elsewhere on the board
M1_ENC_B: U1.57 (PB5); also elsewhere on the board
M1_ENC_Z: U1.40 (PC9); also elsewhere on the board
M1_SO1: U1.8 (PC0); also elsewhere on the board
M1_SO2: U1.9 (PC1); also elsewhere on the board
M1_TEMP: U1.25 (PC5); also elsewhere on the board
M2_AH: U1.37 (PC6); also elsewhere on the board
M2_AL: U1.23 (PA7); also elsewhere on the board
M2_BH: U1.38 (PC7); also elsewhere on the board
M2_BL: U1.26 (PB0); also elsewhere on the board
M2_CH: U1.39 (PC8); also elsewhere on the board
M2_CL: U1.27 (PB1); also elsewhere on the board
M2_CS: U1.3 (PC14); also elsewhere on the board
M2_ENC_A: U1.58 (PB6); also elsewhere on the board
M2_ENC_B: U1.59 (PB7); also elsewhere on the board
M2_ENC_Z: U1.4 (PC15); also elsewhere on the board
M2_SO1: U1.11 (PC3); also elsewhere on the board
M2_SO2: U1.10 (PC2); also elsewhere on the board
M2_TEMP: U1.20 (PA4)
unnamed: C24.1, U1.5 (PH0), Y1.3
unnamed: C25.1, U1.6 (PH1), Y1.1
unnamed: C26.1, U1.31 (VCAP_1)
unnamed: C27.1, U1.47 (VCAP_2)
unnamed: C34.1, U4.4 (BP)
unnamed: D1.1 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)
unnamed: D3.2 (A), R20.2
unnamed: J1.A6 (D+), U6.1 (Ud+)
unnamed: J1.A7 (D-), R50.1
unnamed: J1.B6 (D+), R51.1
unnamed: J1.B7 (D-), U6.2 (Ud-)
SPI_MISO: J9.4, J10.4, U1.52 (PC11); also elsewhere on the board
SPI_MOSI: J9.5, J10.5, U1.53 (PC12); also elsewhere on the board
SPI_SCK: J9.3, J10.3, U1.51 (PC10); also elsewhere on the board
VDC: C53.1, C54.1, C55.1, C57.1, C58.1, C59.1, C60.1, C61.1, J7.2, R23.1; also elsewhere on the board
nFAULT: U1.54 (PD2); also elsewhere on the board

Board: 4 copper layers, 60.0 x 55.2 mm, 147 parts (30 on the bottom side), 138 nets.

Other parts of the board:
C156: 100nf; C_0603_1608Metric
REFA: MountingHole_2.2mm_M2_DIN965_Pad
REFB: MountingHole_2.2mm_M2_DIN965_Pad
REFC: MountingHole_2.2mm_M2_DIN965_Pad
REFD: MountingHole_2.2mm_M2_DIN965_Pad

Their connections:
+3.3V: C156.1; also elsewhere on the board
GND: C156.2; also elsewhere on the board

## Code that names these connections

File SoftWare/foc_1.ioc (part):

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Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
Mcu.UserName=STM32F405RGTx
PA10.Signal=S_TIM1_CH3
PA11.Mode=Device_Only
PA11.Signal=USB_OTG_FS_DM
PA12.Mode=Device_Only
PA12.Signal=USB_OTG_FS_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=EXSPI_CS
PA15.Signal=GPIO_Output
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=M1_TEMP
PA4.Signal=ADCx_IN4
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=VBUS_S
PA6.Signal=ADCx_IN6
PA7.Mode=PWM Generation1 CH1 CH1N
PA7.Signal=TIM8_CH1N
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.Mode=PWM Generation2 CH2 CH2N
PB0.Signal=TIM8_CH2N
PB1.Mode=PWM Generation3 CH3 CH3N
PB1.Signal=TIM8_CH3N
PB10.Mode=Asynchronous
PB10.Signal=USART3_TX
PB11.Mode=Asynchronous
PB11.Signal=USART3_RX
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=EN_GATE
PB12.Signal=GPIO_Output
PB13.Mode=PWM Generation1 CH1 CH1N
PB13.Signal=TIM1_CH1N
PB14.Mode=PWM Generation2 CH2 CH2N
PB14.Signal=TIM1_CH2N
PB15.Mode=PWM Generation3 CH3 CH3N
PB15.Signal=TIM1_CH3N
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=M0_ENC_A
PB4.Signal=GPIO_Input
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=M0_ENC_B
PB5.Signal=GPIO_Input
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=M1_ENC_A
PB6.Signal=GPIO_Input
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=M1_ENC_B
PB7.Signal=GPIO_Input
PB8.Mode=CAN_Activate
PB8.Signal=CAN1_RX
PB9.Mode=CAN_Activate
PB9.Signal=CAN1_TX
PC0.GPIOParameters=GPIO_Label
PC0.GPIO_Label=M0_SO1
PC0.Signal=ADCx_IN10
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=M0_SO2
PC1.Signal=ADCx_IN11
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
PC13-ANTI_TAMP.GPIOParameters=GPIO_Label
PC13-ANTI_TAMP.GPIO_Label=M0_CS
PC13-ANTI_TAMP.Signal=GPIO_Output
PC14-OSC32_IN.GPIOParameters=GPIO_Label
PC14-OSC32_IN.GPIO_Label=M1_CS
PC14-OSC32_IN.Signal=GPIO_Output
PC15-OSC32_OUT.GPIOParameters=GPIO_Label
PC15-OSC32_OUT.GPIO_Label=M1_ENC_Z
PC15-OSC32_OUT.Signal=GPIO_Input
PC2.GPIOParameters=GPIO_Label
PC2.GPIO_Label=M1_SO2
PC2.Signal=ADCx_IN12
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=M1_SO1
PC3.Signal=ADCx_IN13
PC5.GPIOParameters=GPIO_Label
PC5.GPIO_Label=M0_TEMP
PC5.Signal=ADCx_IN15
PC6.Signal=S_TIM8_CH1
PC7.Signal=S_TIM8_CH2
PC8.Signal=S_TIM8_CH3
PC9.GPIOParameters=GPIO_Label
PC9.GPIO_Label=M1_ENC_Z
PC9.Signal=GPIO_Input
PD2.GPIOParameters=GPIO_Label
PD2.GPIO_Label=nFAULT
PD2.Signal=GPIO_Input
PH0-OSC_IN.Mode=HSE-External-Oscillator
PH0-OSC_IN.Signal=RCC_OSC_IN
PH1-OSC_OUT.Mode=HSE-External-Oscillator
PH1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2023-02-17 First push
2023-02-17 Add PCB
2023-02-18 Add Rules
2023-02-18 增加一些功率器件有关的pcb电路
2023-02-18 修改硬件电路
2023-02-18 修改README
2023-02-19 修改一些BUG
2023-02-19 更新一些信号电源
2023-02-19 日常更新
2023-02-19 改bug
2023-02-20 修改pcb中信号部分
2023-02-20 画一部分的信号
2023-02-22 完成PCB
2023-02-23 PCB打样
2023-02-25 添加PI控制器
